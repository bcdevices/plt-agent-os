# packagegroup-bsp-per101

inherit packagegroup

RDEPENDS:${PN} += " rpi-ledctl"
