# packagegroup-modbus

inherit packagegroup

RDEPENDS:${PN} = "\
    mbpoll \
    python3-pymodbus \
"
