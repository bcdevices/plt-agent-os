# python3-click-option-group
SUMMARY = "Recipe to embedded the Python PiP Package click-option-group"
HOMEPAGE ="https://pypi.org/project/click-option-group"
LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f10e5cf198b01ce7c7ed725a55d3b39d"

PYPI_PACKAGE = "click-option-group"
SRC_URI[sha256sum] = "78ee474f07a0ca0ef6c0317bb3ebe79387aafb0c4a1e03b1d8b2b0be1e42fc78"

inherit pypi setuptools3
