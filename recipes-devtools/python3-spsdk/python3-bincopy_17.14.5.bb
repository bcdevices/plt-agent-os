# python3-bincopy
SUMMARY = "Mangling of various file formats that conveys binary information"
HOMEPAGE ="https://github.com/eerimoq/bincopy"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=d9aa4ec07de78abae21c490c9ffe61bd"

PYPI_PACKAGE = "bincopy"
SRC_URI[sha256sum] = "5f4de7c37a3db7adcf3edc4833a223f3356d9bf08be72ec6e431c9f0acd29f18"

inherit pypi setuptools3
