# python3-commentjson
SUMMARY = "Python package to create JSON files with Python and JavaScript style inline comments"
HOMEPAGE ="https://pypi.org/project/commentjson"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.rst;md5=722175c22a1ab5e2e0fd153da885198b"

PYPI_PACKAGE = "commentjson"
SRC_URI[sha256sum] = "42f9f231d97d93aff3286a4dc0de39bfd91ae823d1d9eba9fa901fe0c7113dd4"

inherit pypi setuptools3
