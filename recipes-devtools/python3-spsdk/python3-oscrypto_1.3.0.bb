# python3-oscrypto
SUMMARY = "Recipe to embedded the Python PiP Package oscrypto"
HOMEPAGE ="https://pypi.org/project/oscrypto"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=b5cda97fbd7959ad47a952651a87051a"

PYPI_PACKAGE = "oscrypto"
SRC_URI[sha256sum] = "6f5fef59cb5b3708321db7cca56aed8ad7e662853351e7991fcf60ec606d47a4"

inherit pypi setuptools3
