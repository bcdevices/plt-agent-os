# python3-ruamel.yaml
SUMMARY = "YAML 1.2 loader/dumper"
HOMEPAGE ="https://pypi.org/project/ruamel.yaml"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=034154b7344d15438bc5ed5ee9cc075f"

PYPI_PACKAGE = "ruamel.yaml"
SRC_URI[sha256sum] = "8b7ce697a2f212752a35c1ac414471dc16c424c9573be4926b56ff3f5d23b7af"

inherit pypi setuptools3
