# python3-astunparse
SUMMARY = "An AST unparser for Python"
HOMEPAGE ="https://github.com/simonpercivall/astunparse"
LICENSE = "Python-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=7a7c771110c28a37480b73d07ad6d2a1"

PYPI_PACKAGE = "astunparse"
SRC_URI[sha256sum] = "5ad93a8456f0d084c3456d059fd9a92cce667963232cbf763eac3bc5b7940872"

inherit pypi setuptools3
