# python3-click-command-tree
SUMMARY = "click plugin to show the command tree of a CLI"
HOMEPAGE ="https://pypi.org/project/click-command-tree"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=122e43f068614f96d22b996070de2fd3"

PYPI_PACKAGE = "click-command-tree"
SRC_URI[sha256sum] = "f1ba9c386174dff2fd29949b02a7e1ff7f0a85fca11e737d219eaa60014699a0"

inherit pypi setuptools3
