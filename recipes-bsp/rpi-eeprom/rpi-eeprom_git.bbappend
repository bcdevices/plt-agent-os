# rpi-eeprom_git.bbappend 

# https://git.yoctoproject.org/meta-raspberrypi/commit/?id=065874418d14b1ddcf036aedeac677f191001628
# rpi-eeprom: Update to v2025.07.17-2712
SRCREV = "2349daafacfb7a7abe2cfecf30a49ae837bdf2c6"
PV = "v2025.07.17-2712"
