# rpi-bootfiles.bbappend

# https://git.yoctoproject.org/meta-raspberrypi/commit/?id=b21dd5cd6075e7ea2bd9aa68969907f570545690

# rpi-bootfiles: Update to latest tip as of 20250801
RPIFW_DATE = "20250801"
SRCREV = "95be71b8c0f63f03dc06dd0e4c2e5535e6fb4a93"
SRC_URI[sha256sum] = "8b270b44b7702aae2d60e12b9bb4ea9ce0d9bc34662f7229092b8110d34ef7dd"
